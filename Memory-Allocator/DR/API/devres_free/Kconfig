## fs/bsfs/base/Kconfig
```kconfig
menuconfig BSFS
	bool "BiscuitOS Filesystem support"
	default y
	help
		BiscuitOS Filesystem
```
